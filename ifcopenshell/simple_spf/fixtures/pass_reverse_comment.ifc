Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-05-04T08:08:30
Written by: IfcOpenShell-0.7.0
Made in: IfcOpenShell-0.7.0
Comment: C:\TEMP\path\...\ifc
